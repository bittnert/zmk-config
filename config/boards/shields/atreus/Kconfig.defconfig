## config/boards/shields/atreus/Kconfig.shield
```kconfig
# Copyright (c) 2022 Thomas Bittner
# SPDX-License-Identifier: MIT


config SHIELD_ATREUS
	def_bool $(shields_list_contains,atreus)
```
